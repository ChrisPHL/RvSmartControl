/* GIMP RGB C-Source image dump 1-byte-run-length-encoded (wifiIndicator.c) */

#define WIFIINDICATOR_RUN_LENGTH_DECODE(image_buf, rle_data, size, bpp) do \
{ unsigned int __bpp; unsigned char *__ip; const unsigned char *__il, *__rd; \
  __bpp = (bpp); __ip = (image_buf); __il = __ip + (size) * __bpp; \
  __rd = (rle_data); if (__bpp > 3) { /* RGBA */ \
    while (__ip < __il) { unsigned int __l = *(__rd++); \
      if (__l & 128) { __l = __l - 128; \
        do { memcpy (__ip, __rd, 4); __ip += 4; } while (--__l); __rd += 4; \
      } else { __l *= 4; memcpy (__ip, __rd, __l); \
               __ip += __l; __rd += __l; } } \
  } else if (__bpp == 3) { /* RGB */ \
    while (__ip < __il) { unsigned int __l = *(__rd++); \
      if (__l & 128) { __l = __l - 128; \
        do { memcpy (__ip, __rd, 3); __ip += 3; } while (--__l); __rd += 3; \
      } else { __l *= 3; memcpy (__ip, __rd, __l); \
               __ip += __l; __rd += __l; } } \
  } else { /* RGB16 */ \
    while (__ip < __il) { unsigned int __l = *(__rd++); \
      if (__l & 128) { __l = __l - 128; \
        do { memcpy (__ip, __rd, 2); __ip += 2; } while (--__l); __rd += 2; \
      } else { __l *= 2; memcpy (__ip, __rd, __l); \
               __ip += __l; __rd += __l; } } \
  } } while (0)
static const struct {
  unsigned int 	 width;
  unsigned int 	 height;
  unsigned int 	 bytes_per_pixel; /* 2:RGB16, 3:RGB, 4:RGBA */ 
  unsigned char	 rle_pixel_data[361 + 1];
} wifiIndicator = {
  24, 17, 2,
  "\207\000\000\004,cU\255Y\316\272\326\202<\347\004\333\336Y\316U\255Mk\213\000\000\003\010"
  "B\226\265]\357\212\377\377\003}\357\266\265IJ\206\000\000\003\343\030\226\265\337"
  "\377\216\377\377\003\337\377\266\265$!\203\000\000\002,c<\347\206\377\377\001<\347"
  "\203y\316\002\232\326]\357\206\377\377\005]\357Mk\000\000\060\204\276\367\204\377"
  "\377\003\373\336\323\234\246\061\206\000\000\003\010B\024\245\034\347\204\377\377\003\337"
  "\377Q\214\030\306\203\377\377\002]\357\357{\214\000\000\002Q\214}\357\203\377\377"
  "\006U\255\000\000\070\306\377\377\030\306\303\030\205\000\000\004$!\216sMk\343\030\205\000"
  "\000\004\307\071y\316\377\377U\255\203\000\000\001\020\204\204\000\000\003\014c\030\306}\357"
  "\204\377\377\003]\357\327\275\252R\204\000\000\001\060\204\207\000\000\002\246\061\030\306"
  "\211\377\377\003\337\377\327\275\202\020\211\000\000\002\347\071<\347\214\377\377\001"
  "\373\336\212\000\000\001\367\275\203\377\377\006\333\336U\255\020\204\060\204\226\265"
  "\034\347\203\377\377\001U\255\213\000\000\003\367\275}\357\357{\206\000\000\003Q\214\236"
  "\367U\255\215\000\000\001\347\071\210\000\000\001\307\071\221\000\000\004(B\262\224\222\224\307"
  "\071\223\000\000\002\014c\337\377\202\377\377\002\276\367iJ\223\000\000\001\266\265\202\377"
  "\377\001U\255\225\000\000\002\226\265U\255\213\000\000",
};

